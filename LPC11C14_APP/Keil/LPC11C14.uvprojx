# Keil uVision project LPC11C14.uvprojx, settings and files
target LPC11C14_APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MCU_C14 +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\App;..\Core;..\Library;..\Customer\Schindler
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: ..\Core\LPC11C14.sct
  group App
    ../App/: main.c logic.c
    ../Customer/Schindler/: user.c
  group Library
    ../Library/: DrvIOUART.c IOUART.lib DrvGPIO.c DrvTimer.c DrvUART.c DrvSysClk.c DrvFlash.c DrvCAN.c
  group Core
    ../Core/: core_cm0.c system_LPC11xx.c startup_LPC11xx.s
software components: CMSIS:CORE 5.2.0
